options:
  parameters:
    author: nsk
    generate_options: qt_gui
    id: debug_samples
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: num_samples
  id: variable
  parameters:
    value: '3152000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: y_lim
  id: variable
  parameters:
    value: '400'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/nsk/dev/system_level_simulation/logs/gnu_multi.log
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/nsk/dev/system_level_simulation/logs/gnu_ue1.log
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/nsk/dev/system_level_simulation/logs/gnu_ue2.log
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: /home/nsk/dev/system_level_simulation/logs/gnu_ue3.log
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {}
- name: blocks_head_0_0_0_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {}
- name: blocks_head_0_0_0_0_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"UE1"'
    size: num_samples
    srate: samp_rate
    type: complex
    ylabel: ''
    ymax: y_lim
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Testing"'
    nconnections: '4'
    size: num_samples
    srate: samp_rate
    type: complex
    ylabel: ''
    ymax: y_lim
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Multiple"'
    size: num_samples
    srate: samp_rate
    type: complex
    ylabel: ''
    ymax: y_lim
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"UE2"'
    size: num_samples
    srate: samp_rate
    type: complex
    ymax: y_lim
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"UE3"'
    size: num_samples
    srate: samp_rate
    type: complex
    ylabel: ''
    ymax: y_lim
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_file_source_0_0, '0', blocks_head_0_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_head_0_0_0_0, '0']
- [blocks_file_source_0_2, '0', blocks_head_0_0_0_0_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_0_0_0_0, '3']
- [blocks_head_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_head_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_head_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_head_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_head_0_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_head_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '2']
- [blocks_head_0_0_0_0_0, '0', qtgui_time_sink_x_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
