options:
  parameters:
    generate_options: qt_gui
    id: multi_ue_scenario
    output_language: python
    title: srsRAN_multi_UE
  states: {}

blocks:
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: seed_awgn
  id: variable_qtgui_range
  parameters:
    label: noise
    start: '-1'
    step: '0.002'
    stop: '1'
    value: '0.0120'
  states: {}
- name: slow_down_ratio
  id: variable_qtgui_range
  parameters:
    label: Time Slow Down Ratio
    start: '1'
    step: '1'
    stop: '32'
    value: '1'
  states: {}
- name: ue1_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE1 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: ue2_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE2 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: ue3_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE3 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/nsk/dev/system_level_simulation/logs/gnu_multi.log
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/nsk/dev/system_level_simulation/logs/gnu_ue1.log
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/nsk/dev/system_level_simulation/logs/gnu_ue2.log
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/nsk/dev/system_level_simulation/logs/gnu_ue3.log
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '10240'
    srate: samp_rate
    type: complex
    ylabel: MULTIPLE UES ADD
    ymax: '1000'
    ymin: '-1000'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '10240'
    srate: samp_rate
    type: complex
    ylabel: UE1
    ymax: '1000'
    ymin: '-1000'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '10240'
    srate: samp_rate
    type: complex
    ylabel: UE2
    ymax: '1000'
    ymin: '-1000'
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '10240'
    srate: samp_rate
    type: complex
    ylabel: UE3
    ymax: '1000'
    ymin: '-1000'
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2200
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2300
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2301
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', zeromq_rep_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', zeromq_rep_sink_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', zeromq_rep_sink_0_2, '0']
- [blocks_multiply_const_vxx_0_1_1, '0', zeromq_rep_sink_0_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0_1_1, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [zeromq_req_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_1_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
